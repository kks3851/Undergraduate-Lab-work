# Keil uVision project smallest.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: smallest +hex
  c flags: Optimize=8 SizeSpeed=1
  group source group 1
    ../../../sem 6/project/final/: op2.c
